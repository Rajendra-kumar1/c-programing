# Keil uVision project test.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\linker.sct
  group Source Group 1
    ./day3 svc/: svc1.s
    ./: startup_stm32f407.s
    ./day1/: prog_8bit.s prog_16bit.s prog_32bit.s prog_64bit.s prog5_ldr_str.s prog6_opration_ldr_str.s
    ./Assignment1/: lowercase_uppercase.s prog_if_then.s prog6.s prog7_7th_bit.s Q7_Bit_shift.s reverse.s signed.s strored.s unsigned.s
